# Repository TKG-Tou-Kai-Group/TKG_Wiki

File README.md:

# TKG Wiki

## TKGについて

[CoRE](https://core.scramble-robot.org/)というエンジニア選手権に出場するために結成された東海地方4社の社会人連合チームです。メンバーにはお酒好きが多く、お酒がエネルギー源です。前回大会の目標は「技術賞・個人賞の受賞」でした。革新的技術賞を受賞できましたが、各構成要素の信頼性が低く同盟戦では活躍できませんでした。2024年度は「各構成要素の信頼性向上」により同盟戦で活躍できるロボットを開発することで、総合優勝を目指します！x（旧Twitter）上の#CoREJP_TKGで進捗状況や技術資料を公開中です。微力ながら大会を盛り上げていきますので、どうぞよろしくお願いします。

## 本Wikiの内容について

各出場年毎に作成した設計検討資料をアップロードしています。内容として、ウォーターフォール型開発モデルに基づく方針決定、外部設計、詳細設計の検討資料に加えて、作成したロボットの3DCADデータや回路基板データがあります。詳しい情報は各年毎のREADMEを参照してください。

## KiCad design 2025/詳細検討/22_制御基板(走行)/TCB.kicad_pcb

Parts:
C14: 0.1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
CAN1: JST_XH; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
CLK_C1: 0.1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
D2: RED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D3: YELLOW; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D4: GREEN; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
E1J1: E1; IDC-Header_2x07_P2.54mm_Vertical
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3_ISO14580_Pad
J1: XBee; PinSocket_1x05_P2.54mm_Vertical
LED_R1, LED_R2, LED_R3: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
M1C1, M1C2, M5C1, M6C1, M12C1, M12C2, M35C2, M60C1, M60C2, M94C1, M94C2, M97C1, M97C2: 0.1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
M35C1: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
M94C3, M97C3: 10u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
PWM_chA_J1: JST_XH; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
R2, R3, R4, R8, R10: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RN1, RN2: 4.7k; R_Array_Concave_4x0402
ResC1: 0.1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
Res_R1: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: Reset; SW_Tactile_Straight_KSA0Axx1LFTR
U1: RX631_100pin; LQFP-100_14x14mm_P0.5mm
U2: SSD1306(128x64Display)
U4: SN65HVD230(SOIC); SOIC-8_3.9x4.9mm_P1.27mm
U7: MPU9250_Ali_module; PinSocket_1x10_P2.54mm_Vertical
X1: SG-210STF; Oscillator_SMD_SeikoEpson_SG210-4Pin_2.5x2.0mm

Connections:
+3V3: C14.1, CLK_C1.1, E1J1.8, J1.3, M1C1.1, M1C2.1, M6C1.1, M12C1.2, M12C2.2, M35C1.1, M35C2.1, M60C1.2, M60C2.2, M94C1.1, M94C2.1, M94C3.1, M97C1.2, M97C2.2, M97C3.2, R8.1, R10.1, RN1.1 (R1.1), RN1.2 (R2.1), RN1.3 (R3.1), RN1.4 (R4.1), RN2.8 (R1.2), Res_R1.2, U1.1 (VREFH), U1.6 (VBATT), U1.14 (VCC), U1.35 (VCC_USB), U1.60 (VCC), U1.96 (VREFH0), U1.97 (AVCC0), U2.2 (VCC), U4.3 (VCC), U7.1 (Vcc), X1.4 (Vcc); also elsewhere on the board
/ADC5: U1.89 (P45/AN5/IRQ13-B); also elsewhere on the board
/EMLE: E1J1.4, RN2.3 (R3.1), U1.2 (EMLE)
/ESTOP: U1.15 (P35/NMI); also elsewhere on the board
/IIC2_SCL: U1.30 (P16/USB0_VBUS), U2.3 (SCL)
/IIC2_SDA: U1.29 (P17/TXD3), U2.4 (SDA)
/LED_GREEN: LED_R3.1, U1.56 (PB4)
/LED_RED: LED_R1.1, U1.54 (PB6)
/LED_YELLOW: LED_R2.1, U1.55 (PB5/TXD0)
/MD: E1J1.7, RN1.6 (R3.2), U1.7 (MD/FINED)
/MISOB: U1.75 (PE3); also elsewhere on the board
/MOSIA: U1.46 (PC6), U7.4 (MOSI)
/MOSIB: U1.72 (PE6); also elsewhere on the board
/OPRON: U1.33 (P13/TXD2-A); also elsewhere on the board
/PWM_chA: PWM_chA_J1.2, R3.1, R10.2, U1.70 (PA0)
/PWON: U1.31 (P15/RXD1); also elsewhere on the board
/RES#: E1J1.13, ResC1.1, Res_R1.1, SW1.2, U1.10 (RES#)
/RSPCKA: U1.47 (PC5), U7.3 (RSPCK)
/RSPCKB: U1.73 (PE5); also elsewhere on the board
/Rx1: U1.27 (P21/RXD0); also elsewhere on the board
/Rx2: U1.50 (PC2); also elsewhere on the board
/Rx3: J1.4, U1.17 (P33/IRQ3)
/SSLA0: U1.48 (PC4), U7.9 (CS)
/SSLB0: U1.74 (PE4); also elsewhere on the board
/TCK: E1J1.1, RN1.8 (R1.2), U1.21 (P27/TCK)
/TD0: E1J1.5, RN1.7 (R2.2), U1.22 (P26/TDO/TXD1)
/TDI: E1J1.11, RN2.1 (R1.1), U1.20 (P30/TDI/RXD1)
/TMS: E1J1.9, RN1.5 (R4.2), U1.19 (P31/TMS)
/TRST#: E1J1.3, RN2.4 (R4.1), U1.16 (P34/TRST#)
/Tx1: U1.28 (P20/TXD0); also elsewhere on the board
/Tx3: J1.5, U1.18 (P32/IRQ2)
/XTAL: U1.13 (P36/XTAL), X1.3 (OUT)
//PWM_chA: PWM_chA_J1.3, R2.1, R8.2, U1.69 (PA1)
CAN_RX: U1.39 (P55), U4.4 (R)
CAN_TX: U1.40 (P54), U4.1 (D)
GND: C14.2, CLK_C1.2, D2.1 (K), D3.1 (K), D4.1 (K), E1J1.2, E1J1.12, E1J1.14, H1.1, H2.1, H3.1, H4.1, J1.1, M1C1.2, M1C2.2, M5C1.2, M6C1.2, M12C1.1, M12C2.1, M35C1.2, M35C2.2, M60C1.1, M60C2.1, M94C1.2, M94C2.2, M94C3.2, M97C1.1, M97C2.1, M97C3.1, PWM_chA_J1.1, R2.2, R3.2, R4.1, RN2.5 (R4.2), RN2.6 (R3.2), RN2.7 (R2.2), ResC1.2, SW1.1, U1.3 (VREFL), U1.12 (VSS), U1.38 (VSS_USB), U1.62 (VSS), U1.94 (VREFL0), U1.99 (AVSS0), U2.1 (GND), U4.2 (GND), U7.2 (GND), X1.2 (GND); also elsewhere on the board
unnamed: CAN1.1, R6.1, U4.6 (CANL)
unnamed: CAN1.2, R6.2, U4.7 (CANH)
unnamed: D2.2 (A), LED_R1.2
unnamed: D3.2 (A), LED_R2.2
unnamed: D4.2 (A), LED_R3.2
unnamed: M5C1.1, U1.5 (VCL)
unnamed: R4.2, U4.8 (Rs)
UB: E1J1.10, RN2.2 (R2.1), U1.45 (PC7), U7.7 (MISO)

Notes on the sheet:
IMU (MOSIAはUB端子経由でプルアップされていることに注意)
CRX1
CTX1
LCD
状態表示灯
取付穴
PUしてN-chオープンドレイン出力とすることでLED駆動する
シリアル通信(3V3) Debug用XBee接続

Parts:
ADM_C1: 0.1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C6, C7, C8, C9: 0.1u 10V; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C11, C12, C13: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: BZT52C3V6; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
ESTOP1: JST_XH; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
OPRON1: JST_XH; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
PWON1: JST_XH; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
R7: TBD; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12, R30: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13, R15: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RS232C_J1: JST_XH; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
TKGCOM_J1, TKGCOM_J2: JST_XH; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
U10: ADM3202ARUZ; TSSOP-16_4.4x5mm_P0.65mm

Connections:
+3V3: ADM_C1.1, D1.1 (K), R12.2, R30.2, U10.16 (VCC); also elsewhere on the board
+5V: OPRON1.2, PWON1.2, TKGCOM_J1.2, TKGCOM_J2.2; also elsewhere on the board
/ADC5: C13.1, R15.1; also elsewhere on the board
/DataTransfer/CoREjpEXT_In: TKGCOM_J1.3, TKGCOM_J2.3, U10.8 (R2IN)
/ESTOP: C11.1, ESTOP1.2, R30.1; also elsewhere on the board
/OPRON: C12.1, R7.1, R13.1; also elsewhere on the board
/PWON: PWON1.3; also elsewhere on the board
/Rx1: U10.12 (R1OUT); also elsewhere on the board
/Rx2: U10.9 (R2OUT); also elsewhere on the board
/Tx1: U10.11 (T1IN); also elsewhere on the board
GND: ADM_C1.2, C8.2, C9.2, C11.2, C12.2, C13.2, ESTOP1.1, OPRON1.1, PWON1.1, R7.2, RS232C_J1.1, TKGCOM_J1.1, TKGCOM_J2.1, U10.10 (T2IN), U10.15 (GND); also elsewhere on the board
unnamed: C6.1, U10.1 (C1+)
unnamed: C6.2, U10.3 (C1-)
unnamed: C7.1, U10.4 (C2+)
unnamed: C7.2, U10.5 (C2-)
unnamed: C8.1, U10.6 (VS-)
unnamed: C9.1, U10.2 (VS+)
unnamed: D1.2 (A), PWON1.4, R15.2
unnamed: OPRON1.3, R12.1, R13.2
unnamed: RS232C_J1.2, U10.13 (R1IN)
unnamed: RS232C_J1.3, U10.14 (T1OUT)

Notes on the sheet:
リセット端子が必要になった際に拡張できるように1ピン増やした
公式基板の仕様が不明のため合わせられるようにしておく
(ToDo)ﾌﾟﾙﾀﾞｳﾝ抵抗を外すか、入力インピーダンス計算すること
受信機信号入力(CoREjp)
E-STOP

Parts:
C5: 10n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
Enc_chA_J1: JST_XH; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
LTC_C4: 0.1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
R1, R5, R9: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16, R17: 60.1; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
T4: DLW43SH101XK2
U8: LTC6820; MSOP-16_3x4mm_P0.5mm

Connections:
+3V3: Enc_chA_J1.2, LTC_C4.1, R1.2, U8.1 (EN), U8.6 (VCCS), U8.8 (PHA), U8.9 (VCC), U8.12 (MSTR); also elsewhere on the board
/MISOB: R1.1, U8.3 (MISO); also elsewhere on the board
/MOSIB: U8.2 (MOSI); also elsewhere on the board
/RSPCKB: U8.4 (SCK); also elsewhere on the board
/SSLB0: U8.5 (/CS); also elsewhere on the board
GND: C5.2, Enc_chA_J1.1, LTC_C4.2, R9.2, U8.7 (POL), U8.13 (SLOW), U8.14 (GND); also elsewhere on the board
unnamed: C5.1, R16.2, R17.1
unnamed: Enc_chA_J1.3, T4.2 (AB)
unnamed: Enc_chA_J1.4, T4.1 (AA)
unnamed: R5.1, U8.16 (IBIAS)
unnamed: R5.2, R9.1, U8.15 (ICMP)
unnamed: R16.1, T4.3 (SA), U8.11 (IP)
unnamed: R17.2, T4.4 (SB), U8.10 (IM)

Notes on the sheet:
AS5048A(SPI)
本当にSLOW端子設定はこっちでないとダメ？

Board: 2 copper layers, 75.0 x 45.0 mm, 87 parts (0 on the bottom side), 64 nets.

Other parts of the board:
5V_J1, 5V_J2: JST XH; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
C1: 100u; CP_Radial_D8.0mm_P5.00mm
D10: BLUE; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
LED_R4: 4k7; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RegC1: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
RegC2: 22u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
U3: AZ1086H-3.3; SOT-223-3_TabPin2

Their connections:
+3V3: RegC2.1, U3.2 (Vout); also elsewhere on the board
+5V: 5V_J1.2, 5V_J2.2, C1.1, LED_R4.1, RegC1.1, U3.3 (Vin); also elsewhere on the board
GND: 5V_J1.1, 5V_J2.1, C1.2, D10.1 (K), RegC1.2, RegC2.2, U3.1 (Gnd); also elsewhere on the board
unnamed: D10.2 (A), LED_R4.2

## KiCad design 2025/詳細検討/21_電源制御基板/ECcircuit.kicad_pcb

Parts:
C1: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2: 0.01uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4: 0.1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C6: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7, C8, C10, C13: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9, C11: (DIP)100uF; CP_Radial_D10.0mm_P5.00mm
C14: (DIP)10uF50V; C_Disc_D7.5mm_W2.5mm_P5.00mm
D2: LED Red; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D5: LED Blue; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
F1: Polyfuse; Fuse_Bourns_MF-RG400
F2: Keystone Electronics 3568-10; Fuseholder_Blade_Mini_Keystone_3568
F3: Polyfuse(AKI-112911); Fuse_Bourns_MF-RG400
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
J1, J7, J9: ControlInput; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J2: Battery IN; AMASS_XT60-M_1x02_P7.20mm_Vertical
J10, J11, J12: JST XH; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
JP1, JP2: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
R1: 91k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R3, R4, R13: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 6.8k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10: (DIP)4.7k; R_Axial_DIN0411_L9.9mm_D3.6mm_P15.24mm_Horizontal
R30: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SSSS213202
SW2: ESTOP_XH(JST); JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
U1: TAR5SB33; TSOP-5_1.65x3.05mm_P0.95mm
U2: PC817; DIP-4_W7.62mm
U3: Si8932; SOIC-8_3.9x4.9mm_P1.27mm
U4: 74LVC2G08; SSOP-8_2.95x2.8mm_P0.65mm
U5: MIWI10-24S05; DIP-24_W15.24mm
U6: BP5293-x; TO-220-3_Vertical

Connections:
+3.3V: C1.1, C8.1, U1.5 (Vout), U4.8 (VCC)
+5V: C6.1, C7.1, C9.1, D5.2 (A), J1.2, J7.2, J9.2, J10.2, J11.2, J12.2, U1.1 (Vin), U1.3 (Control), U3.8 (VDDB), U5.14 (+Vout)
+5VP: C10.1, U3.1 (VDDA), U6.3 (VO)
+BATT: D2.2 (A), F1.1, F2.2, F3.1, R1.1; also elsewhere on the board
/PWON: J1.3, JP1.1 (A), JP2.1 (A), R2.2, U4.1
/PWON2: J7.3, JP1.2 (B), R13.2, U4.2
/PWON3: J9.3, JP2.2 (B), R3.2, U4.6
/VoltageDetect: J1.4, J7.4, J9.4, U3.7 (AOP)
GND: C1.2, C2.1, C4.2, C6.2, C7.2, C8.2, C9.2, J1.1, J7.1, J9.1, J10.1, J11.1, J12.1, R2.1, R3.1, R13.1, R30.1, U1.2 (GND), U2.2, U3.5 (GNDB), U3.6 (AON/GND), U4.4 (GND), U5.16 (-Vout)
GNDPWR: C10.2, C11.2, C13.2, C14.2, J2.1, R5.2, R10.1, SW1.3 (C), U2.3, U3.3 (NC), U3.4 (GNDA), U5.2 (-Vin), U5.3 (-Vin), U6.2 (GND); also elsewhere on the board
unnamed: C2.2, U1.4 (NOISE)
unnamed: C4.1, R4.2, U2.1
unnamed: C11.1, C13.1, F1.2, U5.22 (+Vin), U5.23 (+Vin)
unnamed: C14.1, F3.2, U6.1 (VI)
unnamed: D2.1 (K), R10.2
unnamed: D5.1 (K), R30.2
unnamed: F2.1, J2.2
unnamed: R1.2, R5.1, U3.2 (VIN)
unnamed: R4.1, U4.3
unnamed: SW1.2 (B), SW2.1 (A), U2.4
unnamed: U4.5, U4.7
PW_Control: SW2.2 (B); also elsewhere on the board

Notes on the sheet:
ヒューズの代わりに電流センサを入れれば、電流計測も可能 30A定格な点に注意
PWON信号無視用
なるべくショート防止のためにDIP部品を使用する
[参考] https://memoteki.net/archives/1352#index_id4 https://robotry.hatenablog.com/entry/2020/06/05/200000 (分圧抵抗)http://sim.okawa-denshi.jp/rercal.php
https://akizukidenshi.com/catalog/g/gI-13765/
1次側2mAとする(順方向電圧1.2Vで計算) 3.3V：ON,0V：OFF
バッテリ電圧検出

Parts:
C3: 0.1uF(1608); C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D3: SBM1045VSS; D_DO-201_P15.24mm_Horizontal
D7, D8: U1ZB15; D_SMB_Handsoldering
J3, J4: Output; AMASS_XT60-F_1x02_P7.20mm_Vertical
J5, J6, J8: Output; AMASS_XT30U-F_1x02_P5.0mm_Vertical
Q2, Q3: 2SJ555; TO-3P-3_Vertical
R6: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7: TBD; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8, R9: 51; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
+BATT: C3.1, D3.1 (K), D7.1 (K), D8.1 (K), Q2.3 (S), Q3.3 (S), R6.1; also elsewhere on the board
GNDPWR: J3.1, J4.1, J5.1, J6.1, J8.1; also elsewhere on the board
unnamed: C3.2, R6.2, R7.1, R8.1, R9.1
unnamed: D3.2 (A), J3.2, J4.2, J5.2, J6.2, J8.2, Q2.2 (D), Q3.2 (D)
unnamed: D7.2 (A), Q2.1 (G), R8.2
unnamed: D8.2 (A), Q3.1 (G), R9.2
PW_Control: R7.2; also elsewhere on the board

Notes on the sheet:
突入電流防止用コンデンサ(ソフト充電) https://www.rohm.co.jp/electronics-basics/transistors/tr_what8 https://detail-infomation.com/load-switch/
Vgsの絶対最大定格が±20Vなので12V~14Vとなるような抵抗を選定すること LiPo(6cell) 13kΩ( 4.2V*6=25.2V で14.2Vとなる) →実測結果は24V時13.49V
せん頭電流-240Aのため、1個で問題ない (異常に対する対処はヒューズ)

Board: 2 copper layers, 70.0 x 70.0 mm, 60 parts (0 on the bottom side), 26 nets.

## Commit log

2024-06-03 add 2024
2025-02-16 [add] READMEを追加
2025-02-16 [change] STEPファイルのZIP圧縮版を詳細検討フォルダに移動
2025-09-14 upgrade 2025年度資料追加
2025-09-14 Rename fusion360形式は分割圧縮ファイルです7zipで回答してください.txt to fusion360形式は分割圧縮ファイルです7zipで解凍してください
2025-09-14 Rename 01-4_詳細設計レビュー(2024-2025)_v0.7.pdf to 01-4-1_詳細設計レビュー(2024-2025)_v0.7.pdf
    ファイル名修正
2025-09-14 1-4-1_詳細設計レビュー(2024-2025)_v0.7を削除
2025-09-14 詳細設計検討書を再アップロード
